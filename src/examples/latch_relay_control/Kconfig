## src/examples/latch_relay_control/Kconfig
```kconfig
menuconfig EXAMPLES_LATCH_RELAY_CONTROL
	bool "latch_relay_control"
	default y
	---help---
		Enable support for latch relay control
```
